Commit message: started base_link

File: dev_ws/src/common/urdf_pkg/urdf_pkg/test.urdf.xacro (robot description, xacro)
@@ -4,3 +4,4 @@
 <visual>
     <geometry>
-    <box size = 2>
+        <box size>
+    <geometry>
